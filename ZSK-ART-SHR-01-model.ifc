Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:49+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Оборудование благоустройства, ZSK-ART-SHR-01 Шар города «Карта города»
In: Площадка
Description: Оборудование благоустройства. Шар города «Карта города»; Material: Сталь, порошковое покрытие
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-ART-SHR-01; ModelReference: Шар города «Карта города»; ProductionYear: 2026; ArticleNumber: ZSK-ART-SHR-01
ORION_Изделие - Артикул: ZSK-ART-SHR-01; Артикул прежний: SD-ART-SHR-01; Наименование: Шар города «Карта города»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Высота 4–6 м (под площадку); Материал: Сталь, порошковое покрытие; Исполнение: Индивидуально под город; Цена: Стоимость по запросу; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/art-city-ball/30600; Код КСИ: CPr>EDFC; Класс КСИ: Арт-объекты; Коды КСР: …
ADSK - ADSK_Наименование: Шар города «Карта города»; ADSK_Марка: ZSK-ART-SHR-01; ADSK_Код изделия: ZSK-ART-SHR-01; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Сталь, порошковое покрытие; ADSK_URL страницы изделия: https://зск.рф/catalog/art-city-ball/30600
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDFC; ZSK_Артикул_прежний: SD-ART-SHR-01
Qto_ORION - Длина: 4000 mm; Ширина: 6000 mm; Высота: 0 mm
